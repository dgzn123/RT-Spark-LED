# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F407xx, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, USE_HAL_DRIVER, __RTTHREAD__, RT_USING_LIBC, RT_USING_ARMLIBC
  c include: ..\..\..\..\RT-Thread\components\drivers\include;applications;packages\CMSIS-Core-latest\Include;packages\stm32f4_cmsis_driver-latest\Include;board;..\..\..\..\RT-Thread\components\drivers\include;..\..\..\..\RT-Thread\components\drivers\phy;board\CubeMX_Config\Inc;libraries\HAL_Drivers\drivers;..\..\..\..\RT-Thread\libcpu\arm\common;..\..\..\..\RT-Thread\components\drivers\include;.;..\..\..\..\RT-Thread\components\drivers\smp_call;..\..\..\..\RT-Thread\libcpu\arm\cortex-m4;board\ports;packages\stm32f4_hal_driver-latest\Inc;..\..\..\..\RT-Thread\components\net\utest;..\..\..\..\RT-Thread\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\RT-Thread\include;..\..\..\..\RT-Thread\components\libc\posix\ipc;packages\stm32f4_hal_driver-latest\Inc\Legacy;..\..\..\..\RT-Thread\components\libc\posix\io\poll;..\..\..\..\RT-Thread\components\drivers\include;..\..\..\..\RT-Thread\components\drivers\include;..\..\..\..\RT-Thread\components\drivers\include;libraries\HAL_Drivers;..\..\..\..\RT-Thread\components\libc\compilers\common\extension;libraries\HAL_Drivers\drivers\config;..\..\..\..\RT-Thread\components\libc\posix\io\epoll;..\..\..\..\RT-Thread\components\drivers\include;..\..\..\..\RT-Thread\components\drivers\include;..\..\..\..\RT-Thread\components\libc\compilers\common\include;..\..\..\..\RT-Thread\components\finsh;..\..\..\..\RT-Thread\components\libc\posix\io\eventfd
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../../../RT-Thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../RT-Thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../../RT-Thread/components/drivers/core/: device.c
    ../../../../RT-Thread/components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../RT-Thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../RT-Thread/components/drivers/misc/: rt_drv_pwm.c
    ../../../../RT-Thread/components/drivers/pin/: dev_pin.c
    ../../../../RT-Thread/components/drivers/serial/: dev_serial.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    libraries/HAL_Drivers/: drv_common.c
  group Finsh
    ../../../../RT-Thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../../RT-Thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../RT-Thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../RT-Thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../RT-Thread/src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group STM32F4-CMSIS
    packages/stm32f4_cmsis_driver-latest/Source/Templates/: system_stm32f4xx.c
    packages/stm32f4_cmsis_driver-latest/Source/Templates/arm/: startup_stm32f407xx.s
  group STM32F4-HAL
    packages/stm32f4_hal_driver-latest/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_lptim.c
